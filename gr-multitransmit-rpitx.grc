<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gr_multitransmit_rpitx</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Transmitter for RpiTX</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>am_on</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>2,0</value></param>
<param><key>label</key><value>AM</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ctcss_tone</value></param>
<param><key>value</key><value>100</value></param>
<param><key>gui_hint</key><value>10,1</value></param>
<param><key>label</key><value>CTCSS Tone</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>67</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>254.1</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>enable_test_tone</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>11,0</value></param>
<param><key>label</key><value>Test Tone</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>enable_tone</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>10,0</value></param>
<param><key>label</key><value>CTCSS Tone Enable</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>high_frequency_cutoff</value></param>
<param><key>value</key><value>2800</value></param>
<param><key>gui_hint</key><value>7,1</value></param>
<param><key>label</key><value>High Frequency Cutoff</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>audio_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>low_frequency_cutoff</value></param>
<param><key>value</key><value>200</value></param>
<param><key>gui_hint</key><value>7,0</value></param>
<param><key>label</key><value>Low Frequency Cutoff</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>audio_rate/2</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>lsb_on</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>6,0</value></param>
<param><key>label</key><value>LSB</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>nfm_on</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>3,0</value></param>
<param><key>label</key><value>NFM</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>ptt</value></param>
<param><key>value</key><value>False</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
<param><key>label</key><value>Push To Talk</value></param>
<param><key>pressed</key><value>True</value></param>
<param><key>released</key><value>False</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>ptt_lock</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
<param><key>label</key><value>PTT Lock</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rpitx_frequency_correction</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>13,0</value></param>
<param><key>label</key><value>RpiTX Frequency Correction</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-24</value></param>
<param><key>step</key><value>.1</value></param>
<param><key>stop</key><value>24</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>test_tone_frequency</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>gui_hint</key><value>11,1</value></param>
<param><key>label</key><value>Tone Frequency</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>audio_rate</value></param>
<param><key>widget</key><value>counter</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>usb_on</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>5,0</value></param>
<param><key>label</key><value>USB</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>wfm_on</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>4,0</value></param>
<param><key>label</key><value>WFM</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>Receive_Audio_Mute</value></param>
<param><key>const</key><value>not ptt</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>Receive_Audio_Mute_0</value></param>
<param><key>const</key><value>not ptt_lock</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_const_source_x</key>
<param><key>id</key><value>analog_const_source_x_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>analog_nbfm_tx</key>
<param><key>id</key><value>analog_nbfm_tx_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>max_dev</key><value>5e3</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>quad_rate</key><value>audio_rate*2</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>0.1</value></param>
<param><key>freq</key><value>ctcss_tone</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>.3</value></param>
<param><key>freq</key><value>test_tone_frequency</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_SIN_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_2</value></param>
<param><key>amp</key><value>1 if am_on else 0</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_3</value></param>
<param><key>amp</key><value>1.8 if usb_on else 0</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_3_0</value></param>
<param><key>amp</key><value>1.8 if lsb_on else 0</value></param>
<param><key>freq</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_wfm_tx</key>
<param><key>id</key><value>analog_wfm_tx_0</value></param>
<param><key>audio_rate</key><value>audio_rate</value></param>
<param><key>max_dev</key><value>75e3</value></param>
<param><key>fh</key><value>-1.0</value></param>
<param><key>quad_rate</key><value>audio_rate * 4</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0_0</value></param>
<param><key>device_name</key><value>pulse</value></param>
<param><key>samp_rate</key><value>48000</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>high_frequency_cutoff</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>low_frequency_cutoff</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_0_0</value></param>
<param><key>type</key><value>interp_fir_filter_ccc</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>-low_frequency_cutoff</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>low_cutoff_freq</key><value>-high_frequency_cutoff</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>200</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>band_pass_filter</key>
<param><key>id</key><value>band_pass_filter_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>high_cutoff_freq</key><value>high_frequency_cutoff</value></param>
<param><key>low_cutoff_freq</key><value>low_frequency_cutoff</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>400</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>blks2_tcp_sink</key>
<param><key>id</key><value>blks_tcp_sink_0</value></param>
<param><key>addr</key><value>192.168.0.x</value></param>
<param><key>comment</key><value>To connect run rpitx and set frequency on the Raspberry pi for example:

while true; do (nc -l 8011; dd if=/dev/zero bs=4096 count=30); done | sudo rpitx -i- -m IQFLOAT -f 434000

Then set the TCP sink address and port (8011) to the location of the pi running rpitx.</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>server</key><value>False</value></param>
<param><key>port</key><value>8011</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>3</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>enable_test_tone</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>enable_tone</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>nfm_on</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_0</value></param>
<param><key>const</key><value>ptt or ptt_lock</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2_1</value></param>
<param><key>const</key><value>wfm_on</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_3</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_3_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>-rpitx_frequency_correction*1000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>taps</key><value>[1]</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>4e3</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>audio_rate</value></param>
<param><key>width</key><value>500</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>AM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Upper sideband</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_2</value></param>
<param><key>note</key><value>Lower sideband</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_4</value></param>
<param><key>note</key><value>NBFM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_5</value></param>
<param><key>note</key><value>CTCSS Tone</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_6</value></param>
<param><key>note</key><value>WFM</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_7</value></param>
<param><key>note</key><value>Test Tone</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_8</value></param>
<param><key>comment</key><value>*Optional* Use virtual audio cables or analog pass through sound card to mute receive audio on transmit</value></param>
<param><key>note</key><value>RX mute on TX</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_9</value></param>
<param><key>note</key><value>Rpitx Output</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>name</key><value>"Transmitted Signal (I/Q)"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>100</value></param>
<param><key>wintype</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>audio_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>name</key><value>"rpitx signal (I/Q)"</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.01</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>audio_rate*2</value></param>
<param><key>interp</key><value>audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0_0</value></param>
<param><key>decim</key><value>audio_rate*4</value></param>
<param><key>interp</key><value>audio_rate</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>Receive_Audio_Mute</source_block_id><sink_block_id>Receive_Audio_Mute_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>Receive_Audio_Mute_0</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_nbfm_tx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_2</source_block_id><sink_block_id>blocks_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_3</source_block_id><sink_block_id>blocks_multiply_xx_3</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_3_0</source_block_id><sink_block_id>blocks_multiply_xx_3_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_wfm_tx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>Receive_Audio_Mute</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>audio_source_0_0</source_block_id><sink_block_id>blocks_add_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0</source_block_id><sink_block_id>blocks_multiply_xx_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_0_0</source_block_id><sink_block_id>blocks_multiply_xx_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>band_pass_filter_1</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_add_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_2</source_block_id><sink_block_id>analog_wfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_2</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_2</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>band_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>band_pass_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>band_pass_filter_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2_1</source_block_id><sink_block_id>rational_resampler_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_2</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_3</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_3_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blks_tcp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>analog_nbfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0_0</source_block_id><sink_block_id>blocks_add_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
