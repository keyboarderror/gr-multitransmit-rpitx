options:
  parameters:
    generate_options: qt_gui
    id: gr_multitransmit_rpitx
    output_language: python
    title: GRC 3.9 modulator for RpiTX
  states: {}

blocks:
- name: am_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,0
    label: AM
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: ctcss_tone
  id: variable_qtgui_range
  parameters:
    gui_hint: 10,1
    label: CTCSS Tone
    orient: Qt.Horizontal
    start: '67'
    step: '.1'
    stop: '254.1'
    value: '100'
    widget: counter
  states: {}
- name: enable_test_tone
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 11,0
    label: Test Tone
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: enable_tone
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 10,0
    label: CTCSS Tone Enable
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: high_frequency_cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,1
    label: High Frequency Cutoff
    min_len: '100'
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: audio_rate/2
    value: '2800'
  states: {}
- name: low_frequency_cutoff
  id: variable_qtgui_range
  parameters:
    gui_hint: 7,0
    label: Low Frequency Cutoff
    min_len: '100'
    orient: Qt.Horizontal
    start: '1'
    step: '1'
    stop: audio_rate/2
    value: '200'
  states: {}
- name: lsb_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 6,0
    label: LSB
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: nfm_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 3,0
    label: NFM
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: ptt
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 0,0
    label: Push To Talk
    pressed: 'True'
    released: 'False'
    type: int
    value: 'False'
  states: {}
- name: ptt_lock
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 0,1
    label: PTT Lock
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: rpitx_frequency_correction
  id: variable_qtgui_range
  parameters:
    gui_hint: 13,0
    label: RpiTX Frequency Correction
    orient: Qt.Horizontal
    start: '-24'
    step: '.1'
    stop: '24'
    value: '0'
  states: {}
- name: test_tone_frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 11,1
    label: Tone Frequency
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: audio_rate
    value: '1000'
    widget: counter
  states: {}
- name: usb_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 5,0
    label: USB
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: wfm_on
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 4,0
    label: WFM
    'true': 'True'
    type: int
    value: 'False'
  states: {}
- name: Receive_Audio_Mute
  id: blocks_multiply_const_vxx
  parameters:
    const: not ptt
    type: float
  states: {state: disabled}
- name: Receive_Audio_Mute_0
  id: blocks_multiply_const_vxx
  parameters:
    const: not ptt_lock
    type: float
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate*2
    tau: '75e-6'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.1'
    freq: ctcss_tone
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '.3'
    freq: test_tone_frequency
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: 1 if am_on else 0
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: 1.8 if usb_on else 0
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_3_0
  id: analog_sig_source_x
  parameters:
    amp: 1.8 if lsb_on else 0
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: audio_rate * 4
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0_0
  id: audio_source
  parameters:
    device_name: pulse
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: high_frequency_cutoff
    interp: '1'
    low_cutoff_freq: low_frequency_cutoff
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    gain: '1'
    high_cutoff_freq: '-low_frequency_cutoff'
    interp: '1'
    low_cutoff_freq: '-high_frequency_cutoff'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: high_frequency_cutoff
    low_cutoff_freq: low_frequency_cutoff
    samp_rate: audio_rate
    type: fir_filter_ccf
    width: '400'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '.5'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: enable_test_tone
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: enable_tone
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: nfm_on
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: ptt or ptt_lock
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_2_1
  id: blocks_multiply_const_vxx
  parameters:
    const: wfm_on
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_tcp_server_sink_0
  id: blocks_tcp_server_sink
  parameters:
    comment: |-
      To connect run on the pi:

      while true; do (nc 192.168.0.x 8011; dd if=/dev/zero bs=4096 count=30); done | sudo rpitx -i- -m IQFLOAT -f 434000

      Where 192.168.0.x 8011 represents the IP address and port of the host running GRC.
      Configure TCP Server Sink with your network adapter address and port.
    ipaddr: 192.168.0.x
    noblock: 'True'
    port: '8011'
    type: complex
    vlen: '1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-rpitx_frequency_correction*1000'
    decim: '1'
    samp_rate: '48000'
    taps: '[1]'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 4e3
    decim: '1'
    gain: '1'
    samp_rate: audio_rate
    type: fir_filter_fff
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    note: AM
  states: {}
- name: note_1
  id: note
  parameters:
    note: Upper sideband
  states: {}
- name: note_2
  id: note
  parameters:
    note: Lower sideband
  states: {}
- name: note_4
  id: note
  parameters:
    note: NBFM
  states: {}
- name: note_5
  id: note
  parameters:
    note: CTCSS Tone
  states: {}
- name: note_6
  id: note
  parameters:
    note: WFM
  states: {}
- name: note_7
  id: note
  parameters:
    note: Test Tone
  states: {}
- name: note_8
  id: note
  parameters:
    comment: '*Optional* Use virtual audio cables or analog pass through sound card to mute receive audio on transmit'
    note: RX mute on TX
  states: {}
- name: note_9
  id: note
  parameters:
    note: Rpitx Output
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,0
    name: '"Transmitted Signal (I/Q)"'
    rate: '100'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 1,1
    name: '"rpitx signal (I/Q)"'
    showports: 'True'
    type: complex
    update_time: '0.01'
    wintype: firdes.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate*2
    interp: audio_rate
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate*4
    interp: audio_rate
    taps: ''
    type: ccc
  states: {}

connections:
- [Receive_Audio_Mute, '0', Receive_Audio_Mute_0, '0']
- [Receive_Audio_Mute_0, '0', audio_sink_0, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_nbfm_tx_0, '0', blocks_multiply_const_vxx_2, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_2, '1']
- [analog_sig_source_x_3, '0', blocks_multiply_xx_3, '1']
- [analog_sig_source_x_3_0, '0', blocks_multiply_xx_3_0, '1']
- [analog_wfm_tx_0, '0', blocks_multiply_const_vxx_2_1, '0']
- [audio_source_0, '0', Receive_Audio_Mute, '0']
- [audio_source_0_0, '0', blocks_add_xx_2, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_3, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_3_0, '0']
- [band_pass_filter_1, '0', blocks_add_const_vxx_0, '0']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_2, '0']
- [blocks_add_xx_0, '0', low_pass_filter_0, '0']
- [blocks_add_xx_0_0, '0', blocks_multiply_const_vxx_2_0, '0']
- [blocks_add_xx_0_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_add_xx_1, '0', blocks_add_xx_0_0, '1']
- [blocks_add_xx_2, '0', analog_wfm_tx_0, '0']
- [blocks_add_xx_2, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_2, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_2, '1']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_2, '0', rational_resampler_xxx_0_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_2_0, '0', qtgui_sink_x_0, '0']
- [blocks_multiply_const_vxx_2_1, '0', rational_resampler_xxx_0_0_0, '0']
- [blocks_multiply_xx_2, '0', blocks_add_xx_1, '0']
- [blocks_multiply_xx_3, '0', blocks_add_xx_1, '2']
- [blocks_multiply_xx_3_0, '0', blocks_add_xx_1, '1']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_tcp_server_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_add_xx_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', blocks_add_xx_0_0_0, '1']

metadata:
  file_format: 1
